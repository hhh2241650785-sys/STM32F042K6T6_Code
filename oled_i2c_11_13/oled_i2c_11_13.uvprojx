# Keil uVision project oled_i2c_11_13.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F042K6Tx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00001800) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: templete
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=2
  c define: STM32F042,USE_STDPERIPH_DRIVER
  c include: .\CMSIS\Include1;.\CMSIS\Include2;.\StdPeriph_Driver\inc;.\User;.\My_Lib;.\My_Lib\font\.h
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1800
  group Startup
    ./Startup/: startup_stm32f042.s
  group CMSIS
    ./CMSIS/: system_stm32f0xx.c
  group StdPeriph_Driver
    ./StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_can.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_crs.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
    ./StdPeriph_Driver/inc/: stm32f0xx_adc.h stm32f0xx_can.h stm32f0xx_cec.h stm32f0xx_comp.h stm32f0xx_crc.h stm32f0xx_crs.h stm32f0xx_dac.h stm32f0xx_dbgmcu.h stm32f0xx_dma.h stm32f0xx_exti.h stm32f0xx_flash.h stm32f0xx_gpio.h stm32f0xx_i2c.h stm32f0xx_iwdg.h stm32f0xx_misc.h stm32f0xx_pwr.h stm32f0xx_rcc.h stm32f0xx_rtc.h stm32f0xx_spi.h stm32f0xx_syscfg.h stm32f0xx_tim.h stm32f0xx_usart.h stm32f0xx_wwdg.h
  group User
    ./User/: main.c stm32f0xx_conf.h
  group My_Lib
    ./My_Lib/: delay.c delay.h usart.c usart.h i2c.c i2c.h si2c.c si2c.h oled.c oled.h oled_default_font.h oled_font.h
    ./My_Lib/font/.h/: st16.h
